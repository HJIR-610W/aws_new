# IAR project aws_app.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCDiagSuppress: Pe177,Pe550
  ICCARM.CCIncludePath2: ..; ..\Application; ..\Application\Tasks; ..\Application\Communications\LWIP; ..\Application\IO; ..\Application\IO\terminal; ..\Application\Debug; ..\Application\Communications\LWIP; ..\Application\Communications\LWIP\App; ..\Application\Communications\LWIP\Target; ..\Drivers; ..\Drivers\Driver_stm32; ..\Drivers\Driver; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/BSP/Components/lan8742; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ..\Lib; ../FATFS/Target; ../FATFS/App; ../LWIP/App; ../LWIP/Target; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/apps/http; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Middlewares/Third_Party/LwIP/src/apps/snmp; ../Drivers/CMSIS/Include; ..\Drivers\BSP\Components\ADC; ..\Drivers\MCU; ..\Drivers\Utile; ..\Drivers\BSP\Components\fram; ..\Drivers\BSP\Components\rtc; ..\Drivers\BSP\Components\EX_UART; ..\Drivers\BSP\Components\serial_flash; ..\Drivers\BSP\Components\exgpio; ..\Utile; ..\Application\FATFS\App; ..\Application\FATFS\Target; ..\Drivers\Components\lan8742; ..\Drivers\Components\ADC; ..\Drivers\Components\EX_UART; ..\Drivers\Components\exgpio; ..\Drivers\Components\fram; ..\Drivers\Components\rtc; ..\Drivers\Components\serial_flash; ..\Application\IO\cli; ..\Middlewares\modem; ..\Application\Communications\Ethernet; ..\Application\Communications; ..\Application\Sensors; ..\Application\App_drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Application
  OBJCOPY.OOCOutputFile: aws_app.bin
  ILINK.IlinkOutputFile: aws_app.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Application/: app_version.c app_version.h boot_version.c config.c config.h freertos.c freertosCallBack.c fsmc.c gpio.c hj_product_list.h main.c pcb_define.c sdio.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_err.c user_heap.c user_heap.h
  group Application/App_driver
    ../Application/App_drivers/: app_adc.c app_do.c app_flash.c app_fram.c app_rs232.c app_rs485.c app_rtc.c
  group Application/Communications
    ../Application/Communications/: aws_data.c aws_kma2.c aws_kma3.c aws_protocol.c
  group Application/Communications/Ethernet
    ../Application/Communications/Ethernet/: app_socket.c task_client.c task_tcpServer.c
  group Application/Communications/LWIP_APP/App
    ../Application/Communications/LWIP/App/: lwip.c lwip.h
  group Application/Communications/LWIP_APP/Target
    ../Application/Communications/LWIP/Target/: ethernetif.c ethernetif.h lwipopts.h
  group Application/Debug
    ../Application/Debug/: mcu_debug.c mcu_debug.h rtos_debug.c rtos_debug.h
  group Application/FATFS/App
    ../Application/FATFS/App/: fatfs.c fatfs.h
  group Application/FATFS/Target
    ../Application/FATFS/Target/: bsp_driver_sd.c bsp_driver_sd.h fatfs_platform.c fatfs_platform.h ffconf.h sd_diskio.c sd_diskio.h user_diskio.c user_diskio.h
  group Application/IO
    ../Application/IO/: dev_io.c dev_io.h
  group Application/IO/cli
    ../Application/IO/cli/: console_scanf.c fsl_debug_console.c fsl_shell.c
  group Application/IO/terminal
    ../Application/IO/terminal/: terminal.c terminal.h vt100.c vt100_command.h
  group Application/Sensors
    ../Application/Sensors/: app_sensor.c
  group Application/Sensors/barometer
    ../Application/Sensors/barometer/: barometer.c
  group Application/Sensors/humidity
    ../Application/Sensors/humidity/: humidity.c
  group Application/Sensors/rain
    ../Application/Sensors/rain/: rain.c
  group Application/Sensors/snow
    ../Application/Sensors/snow/: hj_snow.c snow.c
  group Application/Sensors/temperature
    ../Application/Sensors/temperature/: temperature.c
  group Application/Sensors/wind_direction
    ../Application/Sensors/wind_direction/: wind_direction.c
  group Application/Sensors/wind_speed
    ../Application/Sensors/wind_speed/: wind_speed.c
  group Application/Tasks
    ../Application/Tasks/: app_console.c app_console.h app_console_test.c app_logging.c task_cmd.c task_comm.c task_console.c task_ethernet.c task_host.c task_isrEvent.c task_logging.c task_measure.c task_monitor.c task_start.c task_system.c task_test.c vir_data.c
  group Drivers/CMSIS
    ../Application/: system_stm32f4xx.c
  group Drivers/Components/adc
    ../Drivers/Components/ADC/: ads1220.c ads1220.h
  group Drivers/Components/EX_UART
    ../Drivers/Components/EX_UART/: TL16C554.c TL16C554.h
  group Drivers/Components/exgpio
    ../Drivers/Components/exgpio/: pcf8575.c pcf8575.h
  group Drivers/Components/fram
    ../Drivers/Components/fram/: fm25cl.c fm25cl.h
  group Drivers/Components/lan
    ../Drivers/Components/lan8742/: lan8742.c lan8742.h
  group Drivers/Components/RS485
    ../Drivers/Components/RS485/: rs485.c
  group Drivers/Components/rtc
    ../Drivers/Components/rtc/: ds1306.c ds1306.h
  group Drivers/Components/serial_flash
    ../Drivers/Components/serial_flash/: ad45db.c ad45db.h
  group Drivers/Driver
    ../Drivers/Driver/: driver_485.c driver_485.h driver_adc.c driver_adc.h driver_adc_reg.c driver_di.c driver_di.h driver_di_def.h driver_do.c driver_do.h driver_do_define.h driver_flash.c driver_flash.h driver_fram.c driver_fram.h driver_freqInput.c driver_freqInput.h driver_gpio_def.h driver_interface.h driver_led.c driver_led.h driver_mux.c driver_rtc.c driver_rtc.h driver_sdi.c driver_sdi.h driver_spi.c driver_spi.h driver_uart.c driver_uart.h driver_uart_def.h
  group Drivers/Driver_stm32
    ../Drivers/Driver_stm32/: driver_stm32_di.c driver_stm32_di.h driver_stm32_do.c driver_stm32_do.h driver_stm32_i2c.c driver_stm32_i2c.h driver_stm32_uart.c driver_stm32_uart.h
  group Drivers/MCU
    ../Drivers/MCU/: mcu_delay.c mcu_interrupt.c mcu_swo.c mcu_swo.h mcu_utile.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
  group EWARM
    ./: startup_stm32f407xx.s
  group Lib/cobs
    ../Lib/cobs/: cobs.c cobs.h
  group Lib/tlsf
    ../Lib/tlsf/: tlsf.c tlsf.h
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: cc949.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/http/: fs.c httpd.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/modem
    ../Middlewares/modem/: ymodem.c
  group System
    ../System/: io_retarget.c syscalls.c
  group Utile
    ../Utile/: crc16_ccitt.c utile.c utile.h utile_stdio.c utile_time.c utile_time.h
